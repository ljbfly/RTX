# Keil uVision project Blinky.uvprojx, settings and files
target Simulation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=1 uC99=1
  c include: .\RTX\Source;.\RTX\Source\ARM;.\RTX\Include;.\RTX\Config;.\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
  group CMSIS
    ./RTX/Source/: rtx_lib.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ./RTX/Source/ARM/: irq_cm3.s
    ./Source/: os_systick.c
    ./RTX/Config/: RTX_Config.c RTX_Config.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1, Compiler:Event Recorder 1.3.0, Compiler:I/O:STDOUT 1.2.0
